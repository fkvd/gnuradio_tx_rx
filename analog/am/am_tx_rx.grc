options:
  parameters:
    author: github.com/fkvd
    comment: Amplitude modulation TX RX
    generate_options: qt_gui
    id: am_tx_rx
    output_language: python
  states: {}

blocks:
- name: amplitude_sensitivity
  id: variable_qtgui_range
  parameters:
    label: amplitude sensitivity
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.7'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Do not change!
    value: '433900000'
  states: {}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    label: Frequency shift
    start: '-100000'
    step: '100'
    stop: '100000'
    value: '32500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Gain (TX)
    start: '0'
    step: '1'
    stop: '89'
    value: '30'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: amplitude_sensitivity
    type: complex
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      48K audio sample
      32-bit float
    file: ../../test.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '10'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1, samp_rate, samp_rate/(2*10), 10000)'
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_gain
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: fff
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '35'
    freq0: center_freq - freq_shift
    gain0: '35'
    gain_mode0: 'False'
    if_gain0: '35'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [dc_blocker_xx_0_0, '0', audio_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
